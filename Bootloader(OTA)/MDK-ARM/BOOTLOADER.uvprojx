# Keil uVision project BOOTLOADER.uvprojx, settings and files
target BOOTLOADER (5060960::V5.06 update 7 (build 960)::.\ARM-COMPLIER-506)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: BOOTLOADER +hex
  AfterMake: keil-build-viewer.exe
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F411xE
  c include: ..\MDK-ARM;..\Core\Inc;..\Drivers\STM32F4xx_StdPeriph_Driver\inc;..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\Drivers\CMSIS\Include;..\Middlewares\RTT;..\Middlewares\EasyLogger\inc;..\Middlewares\Ymodem\inc;..\Tasks\Bootmanager\inc;..\Middlewares\AES\inc;..\Bsp\W25Qxx\inc;..\Bsp\AT24Cxx\inc;..\Middlewares\SFUD\inc;..\Middlewares\SFUD;..\Debug\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Objects\BOOTLOADER.sct
  group Application/User/Core
    ../Core/Src/: main.c tim.c gpio.c uart.c stm32f4xx_it.c flash.c spi.c
    ../Core/Inc/: stm32f4xx_conf.h
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_StdPeriph_Driver
    ../Drivers/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Middlewares/SeggerRTT
    ../Middlewares/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group Middlewares/Easylogger
    ../Middlewares/EasyLogger/src/: elog.c elog_async.c elog_buf.c elog_utils.c
    ../Middlewares/EasyLogger/port/: elog_port.c
  group Middlewares/Ymodem
    ../Middlewares/Ymodem/src/: common.c ymodem.c
  group Middlewares/Aes
    ../Middlewares/AES/src/: aes.c
  group Middlewares/SFUD
    ../Middlewares/SFUD/: sfud_adapter.c
    ../Middlewares/SFUD/src/: sfud.c sfud_sfdp.c
    ../Middlewares/SFUD/port/: sfud_port.c
  group Bsp/W25qxx
    ../Bsp/W25Qxx/src/: w25qxx.c w25qxx_Handler.c
  group Tasks/Bootmanager
    ../Tasks/Bootmanager/src/: bootmanager.c
  group Bsp/AT24Cxx
    ../Bsp/AT24Cxx/src/: at24cxx_driver.c iic.c
